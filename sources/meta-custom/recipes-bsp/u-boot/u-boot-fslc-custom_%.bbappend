FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI_append_mx6 += " file://u-boot-custom-sd-card.patch \
#		        file://u-boot-custom-fdt-name-change.patch "

#SRC_URI_append_mx6 += " file://u-boot-custom-emmc.patch \
#		        file://u-boot-custom-fdt-name-change.patch "
