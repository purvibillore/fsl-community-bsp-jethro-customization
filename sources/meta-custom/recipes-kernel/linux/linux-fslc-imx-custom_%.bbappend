FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI_append_mx6 = " file://kernel_custom_2019_10.patch"
